IMAGE_INSTALL_axxiax86-64 += " \
dpdk-rdk \
dpdk-rdk-dev \
dpdk-rdk-examples \
dpdk-rdk-test \
rdk-user \
rdk-user-dev"
