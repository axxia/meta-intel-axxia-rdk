IMAGE_INSTALL_append_axxiax86-64 += " dpdk-rdk dpdk-rdk-dev dpdk-rdk-examples dpdk-rdk-test"
