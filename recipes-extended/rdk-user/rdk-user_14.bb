require rdk-user.inc

LIC_FILES_CHKSUM = "file://${WORKDIR}/Makefile;md5=a98a7954bf0e5254a363b6b56a4ac54d"

SRC_URI[md5sum] = "d4ab3dfeee8b405ea8388061ea8a5166"
SRC_URI[sha256sum] = "0033a25ea55c21ffeeb787a7c57387f697bf8a30c13ac6842f7142fdd50e46e5"
