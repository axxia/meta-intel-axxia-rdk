# Recipe intended to work with each delivery version (for development purposes)

require rdk-user.inc

LIC_FILES_CHKSUM = "file://${COREBASE}/meta/COPYING.GPLv2;md5=751419260aa954499f7abaabaa882bbe"
